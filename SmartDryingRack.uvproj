# Keil uVision project SmartDryingRack.uvproj, settings and files
target SmartDryingRack (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SmartDryingRack +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group common
    ./common/: common.h
  group globalManager
    ./globalManager/: globalManager.h globalManager.c DH11.c DH11.h
  group adcManager
    ./adcManager/: adcManager.c adcManager.h
  group gsmManager
    ./gsmManager/: gsmManager.c gsmManager.h
  group motorManager
    ./motorManager/: MotorManager.c MotorManager.h
